# Keil uVision project Truma_EBL_Bios_V100.uvprojx, settings and files
target Truma_EBL_Bios_V100 (6190000::V6.19::.\ARMCLANG_6.19)
  device: STM32G491RETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x2001BFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Truma_EBL_Bios_V100 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=1
  c define: USE_HAL_DRIVER,STM32G491xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  group Application/MDK-ARM
    ./: startup_stm32g491xx.s
  group Application/User/Core
    ../Core/Src/: Analog.c Digital.c Comm.c Init.c main.c stm32g4xx_it.c stm32g4xx_hal_msp.c Arvi-Main.cpp
    ../Core/Inc/: Truma_EBL_Bios_V100.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Communications
    ../Core/Communications/: ComunicationManager.cpp Lin.cpp LinClients.cpp
    ../Core/Communications/LinMaster/: LinMaster.cpp
  group Devices
    ../Core/Devices/: Devices.cpp DrainValve.cpp EmptyingValve.cpp EngineBattery1.cpp ExternalLigths.cpp FloorHeating.cpp FreshWater_1.cpp Fridge.cpp Fuses.cpp GrayWater_1.cpp InternalLigths.cpp Inverter.cpp LeisureBattery1.cpp Ligths_1.cpp Multimedia.cpp SolarRegulator1.cpp WaterPump.cpp
  group Errors
    ../Core/Errors/: ErrorManager.cpp
  group Utils
    ../Core/Utils/: Utils.cpp
software components: CMSIS:CORE 6.1.0
